# Keil uVision project test_f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Drivers\BSP\STM3210C_EVAL;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\ATK_MS6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Startup/: startup_stm32f103xb.s
  group User
    ../../User/: stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c curveShow.c main.c utilities.c oledShow.c oledShow.h
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.h key.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Drivers/BSP
    ../../Drivers/BSP/EXTI/: exti.h exti.c
    ../../Drivers/BSP/MOTOR/: motor.c motor.h
    ../../Drivers/BSP/ENCODER/: encoder.h encoder.c
    ../../Drivers/BSP/TIMER/: gtim.h gtim.c
    ../../Drivers/BSP/ATK_MS6050/: atk_ms6050.c atk_ms6050_iic.c
    ../../Drivers/BSP/ATK_MS6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/OLED/: oled.c
